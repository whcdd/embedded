# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: TEST +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;.\Drive;.\Drive\sys;.\Drive\debug_uart5;.\Drive\led;.\Drive\key;.\Drive\motor;.\Drive\config;.\Drive\USB2UART;.\Drive\IMU;.\Drive\command;.\Drive\frame;..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;.\Drive\sdram;..\Drivers\STM32F7xx_HAL_Driver\Inc;.\Drive\IWDG;.\Drive\MCU;.\Drive\MALLOC;.\Drive\NAND;.\Drive\i2c;.\Drive\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
    ./Drive/sys/: clock_init.c
    ./Drive/debug_uart5/: debug_uart5.c
    ./Drive/led/: led.c
    ./Drive/key/: key.c
    ./Drive/motor/: DynamixelMotor.c
    ./Drive/config/: config.c
    ./Drive/USB2UART/: usb2uart.c
    ./Drive/IMU/: MTi_630.c
    ./Drive/command/: commandProcess.c
    ./Drive/frame/: dataFrame.c
    ./Drive/sdram/: sdram.c
    ./Drive/IWDG/: iwdg.c
    ./Drive/MCU/: MCU.c
    ./Drive/MALLOC/: malloc.c
    ./Drive/NAND/: ftl.c nand.c nandtester.c
    ./Drive/i2c/: myiic.c
    ./Drive/delay/: delay.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nand.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
